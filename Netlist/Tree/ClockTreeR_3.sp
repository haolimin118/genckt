*scale(3)	circuit type(Clock R tree)

VIN 1 0 1
R0 1 2 100
R1 2 3 100
R2 2 4 100
R3 2 5 100
R4 3 6 100
R5 3 7 100
R6 3 8 100
R7 4 9 100
R8 4 10 100
R9 4 11 100
R10 5 12 100
R11 5 13 100
R12 5 14 100
R13 6 15 100
R14 6 16 100
R15 6 17 100
R16 7 18 100
R17 7 19 100
R18 7 20 100
R19 8 21 100
R20 8 22 100
R21 8 23 100
R22 9 24 100
R23 9 25 100
R24 9 26 100
R25 10 27 100
R26 10 28 100
R27 10 29 100
R28 11 30 100
R29 11 31 100
R30 11 32 100
R31 12 33 100
R32 12 34 100
R33 12 35 100
R34 13 36 100
R35 13 37 100
R36 13 38 100
R37 14 39 100
R38 14 40 100
R39 14 41 100
R40 15 42 100
R41 15 43 100
R42 15 44 100
R43 16 45 100
R44 16 46 100
R45 16 47 100
R46 17 48 100
R47 17 49 100
R48 17 50 100
R49 18 51 100
R50 18 52 100
R51 18 53 100
R52 19 54 100
R53 19 55 100
R54 19 56 100
R55 20 57 100
R56 20 58 100
R57 20 59 100
R58 21 60 100
R59 21 61 100
R60 21 62 100
R61 22 63 100
R62 22 64 100
R63 22 65 100
R64 23 66 100
R65 23 67 100
R66 23 68 100
R67 24 69 100
R68 24 70 100
R69 24 71 100
R70 25 72 100
R71 25 73 100
R72 25 74 100
R73 26 75 100
R74 26 76 100
R75 26 77 100
R76 27 78 100
R77 27 79 100
R78 27 80 100
R79 28 81 100
R80 28 82 100
R81 28 83 100
R82 29 84 100
R83 29 85 100
R84 29 86 100
R85 30 87 100
R86 30 88 100
R87 30 89 100
R88 31 90 100
R89 31 91 100
R90 31 92 100
R91 32 93 100
R92 32 94 100
R93 32 95 100
R94 33 96 100
R95 33 97 100
R96 33 98 100
R97 34 99 100
R98 34 100 100
R99 34 101 100
R100 35 102 100
R101 35 103 100
R102 35 104 100
R103 36 105 100
R104 36 106 100
R105 36 107 100
R106 37 108 100
R107 37 109 100
R108 37 110 100
R109 38 111 100
R110 38 112 100
R111 38 113 100
R112 39 114 100
R113 39 115 100
R114 39 116 100
R115 40 117 100
R116 40 118 100
R117 40 119 100
R118 41 120 100
R119 41 121 100
R120 41 122 100
R121 42 0 100
R122 42 0 100
R123 42 0 100
R124 43 0 100
R125 43 0 100
R126 43 0 100
R127 44 0 100
R128 44 0 100
R129 44 0 100
R130 45 0 100
R131 45 0 100
R132 45 0 100
R133 46 0 100
R134 46 0 100
R135 46 0 100
R136 47 0 100
R137 47 0 100
R138 47 0 100
R139 48 0 100
R140 48 0 100
R141 48 0 100
R142 49 0 100
R143 49 0 100
R144 49 0 100
R145 50 0 100
R146 50 0 100
R147 50 0 100
R148 51 0 100
R149 51 0 100
R150 51 0 100
R151 52 0 100
R152 52 0 100
R153 52 0 100
R154 53 0 100
R155 53 0 100
R156 53 0 100
R157 54 0 100
R158 54 0 100
R159 54 0 100
R160 55 0 100
R161 55 0 100
R162 55 0 100
R163 56 0 100
R164 56 0 100
R165 56 0 100
R166 57 0 100
R167 57 0 100
R168 57 0 100
R169 58 0 100
R170 58 0 100
R171 58 0 100
R172 59 0 100
R173 59 0 100
R174 59 0 100
R175 60 0 100
R176 60 0 100
R177 60 0 100
R178 61 0 100
R179 61 0 100
R180 61 0 100
R181 62 0 100
R182 62 0 100
R183 62 0 100
R184 63 0 100
R185 63 0 100
R186 63 0 100
R187 64 0 100
R188 64 0 100
R189 64 0 100
R190 65 0 100
R191 65 0 100
R192 65 0 100
R193 66 0 100
R194 66 0 100
R195 66 0 100
R196 67 0 100
R197 67 0 100
R198 67 0 100
R199 68 0 100
R200 68 0 100
R201 68 0 100
R202 69 0 100
R203 69 0 100
R204 69 0 100
R205 70 0 100
R206 70 0 100
R207 70 0 100
R208 71 0 100
R209 71 0 100
R210 71 0 100
R211 72 0 100
R212 72 0 100
R213 72 0 100
R214 73 0 100
R215 73 0 100
R216 73 0 100
R217 74 0 100
R218 74 0 100
R219 74 0 100
R220 75 0 100
R221 75 0 100
R222 75 0 100
R223 76 0 100
R224 76 0 100
R225 76 0 100
R226 77 0 100
R227 77 0 100
R228 77 0 100
R229 78 0 100
R230 78 0 100
R231 78 0 100
R232 79 0 100
R233 79 0 100
R234 79 0 100
R235 80 0 100
R236 80 0 100
R237 80 0 100
R238 81 0 100
R239 81 0 100
R240 81 0 100
R241 82 0 100
R242 82 0 100
R243 82 0 100
R244 83 0 100
R245 83 0 100
R246 83 0 100
R247 84 0 100
R248 84 0 100
R249 84 0 100
R250 85 0 100
R251 85 0 100
R252 85 0 100
R253 86 0 100
R254 86 0 100
R255 86 0 100
R256 87 0 100
R257 87 0 100
R258 87 0 100
R259 88 0 100
R260 88 0 100
R261 88 0 100
R262 89 0 100
R263 89 0 100
R264 89 0 100
R265 90 0 100
R266 90 0 100
R267 90 0 100
R268 91 0 100
R269 91 0 100
R270 91 0 100
R271 92 0 100
R272 92 0 100
R273 92 0 100
R274 93 0 100
R275 93 0 100
R276 93 0 100
R277 94 0 100
R278 94 0 100
R279 94 0 100
R280 95 0 100
R281 95 0 100
R282 95 0 100
R283 96 0 100
R284 96 0 100
R285 96 0 100
R286 97 0 100
R287 97 0 100
R288 97 0 100
R289 98 0 100
R290 98 0 100
R291 98 0 100
R292 99 0 100
R293 99 0 100
R294 99 0 100
R295 100 0 100
R296 100 0 100
R297 100 0 100
R298 101 0 100
R299 101 0 100
R300 101 0 100
R301 102 0 100
R302 102 0 100
R303 102 0 100
R304 103 0 100
R305 103 0 100
R306 103 0 100
R307 104 0 100
R308 104 0 100
R309 104 0 100
R310 105 0 100
R311 105 0 100
R312 105 0 100
R313 106 0 100
R314 106 0 100
R315 106 0 100
R316 107 0 100
R317 107 0 100
R318 107 0 100
R319 108 0 100
R320 108 0 100
R321 108 0 100
R322 109 0 100
R323 109 0 100
R324 109 0 100
R325 110 0 100
R326 110 0 100
R327 110 0 100
R328 111 0 100
R329 111 0 100
R330 111 0 100
R331 112 0 100
R332 112 0 100
R333 112 0 100
R334 113 0 100
R335 113 0 100
R336 113 0 100
R337 114 0 100
R338 114 0 100
R339 114 0 100
R340 115 0 100
R341 115 0 100
R342 115 0 100
R343 116 0 100
R344 116 0 100
R345 116 0 100
R346 117 0 100
R347 117 0 100
R348 117 0 100
R349 118 0 100
R350 118 0 100
R351 118 0 100
R352 119 0 100
R353 119 0 100
R354 119 0 100
R355 120 0 100
R356 120 0 100
R357 120 0 100
R358 121 0 100
R359 121 0 100
R360 121 0 100
R361 122 0 100
R362 122 0 100
R363 122 0 100
.OP
.ENDS
