*scale(50)	circuit type(Coupled RC tree)

VIN0 10 0 0
VIN1 11 0 1
R10 10 20 100
C10 20 0 1p
R11 11 21 100
C11 21 0 1p
C1C 20 21 1p
R20 20 30 100
C20 30 0 1p
R21 21 31 100
C21 31 0 1p
C2C 30 31 1p
R30 30 40 100
C30 40 0 1p
R31 31 41 100
C31 41 0 1p
C3C 40 41 1p
R40 40 50 100
C40 50 0 1p
R41 41 51 100
C41 51 0 1p
C4C 50 51 1p
R50 50 60 100
C50 60 0 1p
R51 51 61 100
C51 61 0 1p
C5C 60 61 1p
R60 60 70 100
C60 70 0 1p
R61 61 71 100
C61 71 0 1p
C6C 70 71 1p
R70 70 80 100
C70 80 0 1p
R71 71 81 100
C71 81 0 1p
C7C 80 81 1p
R80 80 90 100
C80 90 0 1p
R81 81 91 100
C81 91 0 1p
C8C 90 91 1p
R90 90 100 100
C90 100 0 1p
R91 91 101 100
C91 101 0 1p
C9C 100 101 1p
R100 100 110 100
C100 110 0 1p
R101 101 111 100
C101 111 0 1p
C10C 110 111 1p
R110 110 120 100
C110 120 0 1p
R111 111 121 100
C111 121 0 1p
C11C 120 121 1p
R120 120 130 100
C120 130 0 1p
R121 121 131 100
C121 131 0 1p
C12C 130 131 1p
R130 130 140 100
C130 140 0 1p
R131 131 141 100
C131 141 0 1p
C13C 140 141 1p
R140 140 150 100
C140 150 0 1p
R141 141 151 100
C141 151 0 1p
C14C 150 151 1p
R150 150 160 100
C150 160 0 1p
R151 151 161 100
C151 161 0 1p
C15C 160 161 1p
R160 160 170 100
C160 170 0 1p
R161 161 171 100
C161 171 0 1p
C16C 170 171 1p
R170 170 180 100
C170 180 0 1p
R171 171 181 100
C171 181 0 1p
C17C 180 181 1p
R180 180 190 100
C180 190 0 1p
R181 181 191 100
C181 191 0 1p
C18C 190 191 1p
R190 190 200 100
C190 200 0 1p
R191 191 201 100
C191 201 0 1p
C19C 200 201 1p
R200 200 210 100
C200 210 0 1p
R201 201 211 100
C201 211 0 1p
C20C 210 211 1p
R210 210 220 100
C210 220 0 1p
R211 211 221 100
C211 221 0 1p
C21C 220 221 1p
R220 220 230 100
C220 230 0 1p
R221 221 231 100
C221 231 0 1p
C22C 230 231 1p
R230 230 240 100
C230 240 0 1p
R231 231 241 100
C231 241 0 1p
C23C 240 241 1p
R240 240 250 100
C240 250 0 1p
R241 241 251 100
C241 251 0 1p
C24C 250 251 1p
R250 250 260 100
C250 260 0 1p
R251 251 261 100
C251 261 0 1p
C25C 260 261 1p
R260 260 270 100
C260 270 0 1p
R261 261 271 100
C261 271 0 1p
C26C 270 271 1p
R270 270 280 100
C270 280 0 1p
R271 271 281 100
C271 281 0 1p
C27C 280 281 1p
R280 280 290 100
C280 290 0 1p
R281 281 291 100
C281 291 0 1p
C28C 290 291 1p
R290 290 300 100
C290 300 0 1p
R291 291 301 100
C291 301 0 1p
C29C 300 301 1p
R300 300 310 100
C300 310 0 1p
R301 301 311 100
C301 311 0 1p
C30C 310 311 1p
R310 310 320 100
C310 320 0 1p
R311 311 321 100
C311 321 0 1p
C31C 320 321 1p
R320 320 330 100
C320 330 0 1p
R321 321 331 100
C321 331 0 1p
C32C 330 331 1p
R330 330 340 100
C330 340 0 1p
R331 331 341 100
C331 341 0 1p
C33C 340 341 1p
R340 340 350 100
C340 350 0 1p
R341 341 351 100
C341 351 0 1p
C34C 350 351 1p
R350 350 360 100
C350 360 0 1p
R351 351 361 100
C351 361 0 1p
C35C 360 361 1p
R360 360 370 100
C360 370 0 1p
R361 361 371 100
C361 371 0 1p
C36C 370 371 1p
R370 370 380 100
C370 380 0 1p
R371 371 381 100
C371 381 0 1p
C37C 380 381 1p
R380 380 390 100
C380 390 0 1p
R381 381 391 100
C381 391 0 1p
C38C 390 391 1p
R390 390 400 100
C390 400 0 1p
R391 391 401 100
C391 401 0 1p
C39C 400 401 1p
R400 400 410 100
C400 410 0 1p
R401 401 411 100
C401 411 0 1p
C40C 410 411 1p
R410 410 420 100
C410 420 0 1p
R411 411 421 100
C411 421 0 1p
C41C 420 421 1p
R420 420 430 100
C420 430 0 1p
R421 421 431 100
C421 431 0 1p
C42C 430 431 1p
R430 430 440 100
C430 440 0 1p
R431 431 441 100
C431 441 0 1p
C43C 440 441 1p
R440 440 450 100
C440 450 0 1p
R441 441 451 100
C441 451 0 1p
C44C 450 451 1p
R450 450 460 100
C450 460 0 1p
R451 451 461 100
C451 461 0 1p
C45C 460 461 1p
R460 460 470 100
C460 470 0 1p
R461 461 471 100
C461 471 0 1p
C46C 470 471 1p
R470 470 480 100
C470 480 0 1p
R471 471 481 100
C471 481 0 1p
C47C 480 481 1p
R480 480 490 100
C480 490 0 1p
R481 481 491 100
C481 491 0 1p
C48C 490 491 1p
R490 490 500 100
C490 500 0 1p
R491 491 501 100
C491 501 0 1p
C49C 500 501 1p
R500 500 510 100
C500 510 0 1p
R501 501 511 100
C501 511 0 1p
C50C 510 511 1p

.OP
.PRINT V(510) V(511)
.ENDS
