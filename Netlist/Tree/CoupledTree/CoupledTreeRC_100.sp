*scale(100)	circuit type(Coupled RC tree)

VIN0 10 0 0
VIN1 11 0 1
R10 10 20 100
C10 20 0 1p
R11 11 21 100
C11 21 0 1p
C1C 20 21 1p
R20 20 30 100
C20 30 0 1p
R21 21 31 100
C21 31 0 1p
C2C 30 31 1p
R30 30 40 100
C30 40 0 1p
R31 31 41 100
C31 41 0 1p
C3C 40 41 1p
R40 40 50 100
C40 50 0 1p
R41 41 51 100
C41 51 0 1p
C4C 50 51 1p
R50 50 60 100
C50 60 0 1p
R51 51 61 100
C51 61 0 1p
C5C 60 61 1p
R60 60 70 100
C60 70 0 1p
R61 61 71 100
C61 71 0 1p
C6C 70 71 1p
R70 70 80 100
C70 80 0 1p
R71 71 81 100
C71 81 0 1p
C7C 80 81 1p
R80 80 90 100
C80 90 0 1p
R81 81 91 100
C81 91 0 1p
C8C 90 91 1p
R90 90 100 100
C90 100 0 1p
R91 91 101 100
C91 101 0 1p
C9C 100 101 1p
R100 100 110 100
C100 110 0 1p
R101 101 111 100
C101 111 0 1p
C10C 110 111 1p
R110 110 120 100
C110 120 0 1p
R111 111 121 100
C111 121 0 1p
C11C 120 121 1p
R120 120 130 100
C120 130 0 1p
R121 121 131 100
C121 131 0 1p
C12C 130 131 1p
R130 130 140 100
C130 140 0 1p
R131 131 141 100
C131 141 0 1p
C13C 140 141 1p
R140 140 150 100
C140 150 0 1p
R141 141 151 100
C141 151 0 1p
C14C 150 151 1p
R150 150 160 100
C150 160 0 1p
R151 151 161 100
C151 161 0 1p
C15C 160 161 1p
R160 160 170 100
C160 170 0 1p
R161 161 171 100
C161 171 0 1p
C16C 170 171 1p
R170 170 180 100
C170 180 0 1p
R171 171 181 100
C171 181 0 1p
C17C 180 181 1p
R180 180 190 100
C180 190 0 1p
R181 181 191 100
C181 191 0 1p
C18C 190 191 1p
R190 190 200 100
C190 200 0 1p
R191 191 201 100
C191 201 0 1p
C19C 200 201 1p
R200 200 210 100
C200 210 0 1p
R201 201 211 100
C201 211 0 1p
C20C 210 211 1p
R210 210 220 100
C210 220 0 1p
R211 211 221 100
C211 221 0 1p
C21C 220 221 1p
R220 220 230 100
C220 230 0 1p
R221 221 231 100
C221 231 0 1p
C22C 230 231 1p
R230 230 240 100
C230 240 0 1p
R231 231 241 100
C231 241 0 1p
C23C 240 241 1p
R240 240 250 100
C240 250 0 1p
R241 241 251 100
C241 251 0 1p
C24C 250 251 1p
R250 250 260 100
C250 260 0 1p
R251 251 261 100
C251 261 0 1p
C25C 260 261 1p
R260 260 270 100
C260 270 0 1p
R261 261 271 100
C261 271 0 1p
C26C 270 271 1p
R270 270 280 100
C270 280 0 1p
R271 271 281 100
C271 281 0 1p
C27C 280 281 1p
R280 280 290 100
C280 290 0 1p
R281 281 291 100
C281 291 0 1p
C28C 290 291 1p
R290 290 300 100
C290 300 0 1p
R291 291 301 100
C291 301 0 1p
C29C 300 301 1p
R300 300 310 100
C300 310 0 1p
R301 301 311 100
C301 311 0 1p
C30C 310 311 1p
R310 310 320 100
C310 320 0 1p
R311 311 321 100
C311 321 0 1p
C31C 320 321 1p
R320 320 330 100
C320 330 0 1p
R321 321 331 100
C321 331 0 1p
C32C 330 331 1p
R330 330 340 100
C330 340 0 1p
R331 331 341 100
C331 341 0 1p
C33C 340 341 1p
R340 340 350 100
C340 350 0 1p
R341 341 351 100
C341 351 0 1p
C34C 350 351 1p
R350 350 360 100
C350 360 0 1p
R351 351 361 100
C351 361 0 1p
C35C 360 361 1p
R360 360 370 100
C360 370 0 1p
R361 361 371 100
C361 371 0 1p
C36C 370 371 1p
R370 370 380 100
C370 380 0 1p
R371 371 381 100
C371 381 0 1p
C37C 380 381 1p
R380 380 390 100
C380 390 0 1p
R381 381 391 100
C381 391 0 1p
C38C 390 391 1p
R390 390 400 100
C390 400 0 1p
R391 391 401 100
C391 401 0 1p
C39C 400 401 1p
R400 400 410 100
C400 410 0 1p
R401 401 411 100
C401 411 0 1p
C40C 410 411 1p
R410 410 420 100
C410 420 0 1p
R411 411 421 100
C411 421 0 1p
C41C 420 421 1p
R420 420 430 100
C420 430 0 1p
R421 421 431 100
C421 431 0 1p
C42C 430 431 1p
R430 430 440 100
C430 440 0 1p
R431 431 441 100
C431 441 0 1p
C43C 440 441 1p
R440 440 450 100
C440 450 0 1p
R441 441 451 100
C441 451 0 1p
C44C 450 451 1p
R450 450 460 100
C450 460 0 1p
R451 451 461 100
C451 461 0 1p
C45C 460 461 1p
R460 460 470 100
C460 470 0 1p
R461 461 471 100
C461 471 0 1p
C46C 470 471 1p
R470 470 480 100
C470 480 0 1p
R471 471 481 100
C471 481 0 1p
C47C 480 481 1p
R480 480 490 100
C480 490 0 1p
R481 481 491 100
C481 491 0 1p
C48C 490 491 1p
R490 490 500 100
C490 500 0 1p
R491 491 501 100
C491 501 0 1p
C49C 500 501 1p
R500 500 510 100
C500 510 0 1p
R501 501 511 100
C501 511 0 1p
C50C 510 511 1p
R510 510 520 100
C510 520 0 1p
R511 511 521 100
C511 521 0 1p
C51C 520 521 1p
R520 520 530 100
C520 530 0 1p
R521 521 531 100
C521 531 0 1p
C52C 530 531 1p
R530 530 540 100
C530 540 0 1p
R531 531 541 100
C531 541 0 1p
C53C 540 541 1p
R540 540 550 100
C540 550 0 1p
R541 541 551 100
C541 551 0 1p
C54C 550 551 1p
R550 550 560 100
C550 560 0 1p
R551 551 561 100
C551 561 0 1p
C55C 560 561 1p
R560 560 570 100
C560 570 0 1p
R561 561 571 100
C561 571 0 1p
C56C 570 571 1p
R570 570 580 100
C570 580 0 1p
R571 571 581 100
C571 581 0 1p
C57C 580 581 1p
R580 580 590 100
C580 590 0 1p
R581 581 591 100
C581 591 0 1p
C58C 590 591 1p
R590 590 600 100
C590 600 0 1p
R591 591 601 100
C591 601 0 1p
C59C 600 601 1p
R600 600 610 100
C600 610 0 1p
R601 601 611 100
C601 611 0 1p
C60C 610 611 1p
R610 610 620 100
C610 620 0 1p
R611 611 621 100
C611 621 0 1p
C61C 620 621 1p
R620 620 630 100
C620 630 0 1p
R621 621 631 100
C621 631 0 1p
C62C 630 631 1p
R630 630 640 100
C630 640 0 1p
R631 631 641 100
C631 641 0 1p
C63C 640 641 1p
R640 640 650 100
C640 650 0 1p
R641 641 651 100
C641 651 0 1p
C64C 650 651 1p
R650 650 660 100
C650 660 0 1p
R651 651 661 100
C651 661 0 1p
C65C 660 661 1p
R660 660 670 100
C660 670 0 1p
R661 661 671 100
C661 671 0 1p
C66C 670 671 1p
R670 670 680 100
C670 680 0 1p
R671 671 681 100
C671 681 0 1p
C67C 680 681 1p
R680 680 690 100
C680 690 0 1p
R681 681 691 100
C681 691 0 1p
C68C 690 691 1p
R690 690 700 100
C690 700 0 1p
R691 691 701 100
C691 701 0 1p
C69C 700 701 1p
R700 700 710 100
C700 710 0 1p
R701 701 711 100
C701 711 0 1p
C70C 710 711 1p
R710 710 720 100
C710 720 0 1p
R711 711 721 100
C711 721 0 1p
C71C 720 721 1p
R720 720 730 100
C720 730 0 1p
R721 721 731 100
C721 731 0 1p
C72C 730 731 1p
R730 730 740 100
C730 740 0 1p
R731 731 741 100
C731 741 0 1p
C73C 740 741 1p
R740 740 750 100
C740 750 0 1p
R741 741 751 100
C741 751 0 1p
C74C 750 751 1p
R750 750 760 100
C750 760 0 1p
R751 751 761 100
C751 761 0 1p
C75C 760 761 1p
R760 760 770 100
C760 770 0 1p
R761 761 771 100
C761 771 0 1p
C76C 770 771 1p
R770 770 780 100
C770 780 0 1p
R771 771 781 100
C771 781 0 1p
C77C 780 781 1p
R780 780 790 100
C780 790 0 1p
R781 781 791 100
C781 791 0 1p
C78C 790 791 1p
R790 790 800 100
C790 800 0 1p
R791 791 801 100
C791 801 0 1p
C79C 800 801 1p
R800 800 810 100
C800 810 0 1p
R801 801 811 100
C801 811 0 1p
C80C 810 811 1p
R810 810 820 100
C810 820 0 1p
R811 811 821 100
C811 821 0 1p
C81C 820 821 1p
R820 820 830 100
C820 830 0 1p
R821 821 831 100
C821 831 0 1p
C82C 830 831 1p
R830 830 840 100
C830 840 0 1p
R831 831 841 100
C831 841 0 1p
C83C 840 841 1p
R840 840 850 100
C840 850 0 1p
R841 841 851 100
C841 851 0 1p
C84C 850 851 1p
R850 850 860 100
C850 860 0 1p
R851 851 861 100
C851 861 0 1p
C85C 860 861 1p
R860 860 870 100
C860 870 0 1p
R861 861 871 100
C861 871 0 1p
C86C 870 871 1p
R870 870 880 100
C870 880 0 1p
R871 871 881 100
C871 881 0 1p
C87C 880 881 1p
R880 880 890 100
C880 890 0 1p
R881 881 891 100
C881 891 0 1p
C88C 890 891 1p
R890 890 900 100
C890 900 0 1p
R891 891 901 100
C891 901 0 1p
C89C 900 901 1p
R900 900 910 100
C900 910 0 1p
R901 901 911 100
C901 911 0 1p
C90C 910 911 1p
R910 910 920 100
C910 920 0 1p
R911 911 921 100
C911 921 0 1p
C91C 920 921 1p
R920 920 930 100
C920 930 0 1p
R921 921 931 100
C921 931 0 1p
C92C 930 931 1p
R930 930 940 100
C930 940 0 1p
R931 931 941 100
C931 941 0 1p
C93C 940 941 1p
R940 940 950 100
C940 950 0 1p
R941 941 951 100
C941 951 0 1p
C94C 950 951 1p
R950 950 960 100
C950 960 0 1p
R951 951 961 100
C951 961 0 1p
C95C 960 961 1p
R960 960 970 100
C960 970 0 1p
R961 961 971 100
C961 971 0 1p
C96C 970 971 1p
R970 970 980 100
C970 980 0 1p
R971 971 981 100
C971 981 0 1p
C97C 980 981 1p
R980 980 990 100
C980 990 0 1p
R981 981 991 100
C981 991 0 1p
C98C 990 991 1p
R990 990 1000 100
C990 1000 0 1p
R991 991 1001 100
C991 1001 0 1p
C99C 1000 1001 1p
R1000 1000 1010 100
C1000 1010 0 1p
R1001 1001 1011 100
C1001 1011 0 1p
C100C 1010 1011 1p

.OP
.PRINT V(1010) V(1011)
.ENDS
