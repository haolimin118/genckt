*scale(3)	circuit type(Clock RC tree)

VIN 1 0 1
R0 1 2 100
C0 2 0 1p
R1 2 3 100
C1 3 0 1p
R2 2 4 100
C2 4 0 1p
R3 2 5 100
C3 5 0 1p
R4 3 6 100
C4 6 0 1p
R5 3 7 100
C5 7 0 1p
R6 3 8 100
C6 8 0 1p
R7 4 9 100
C7 9 0 1p
R8 4 10 100
C8 10 0 1p
R9 4 11 100
C9 11 0 1p
R10 5 12 100
C10 12 0 1p
R11 5 13 100
C11 13 0 1p
R12 5 14 100
C12 14 0 1p
R13 6 15 100
C13 15 0 1p
R14 6 16 100
C14 16 0 1p
R15 6 17 100
C15 17 0 1p
R16 7 18 100
C16 18 0 1p
R17 7 19 100
C17 19 0 1p
R18 7 20 100
C18 20 0 1p
R19 8 21 100
C19 21 0 1p
R20 8 22 100
C20 22 0 1p
R21 8 23 100
C21 23 0 1p
R22 9 24 100
C22 24 0 1p
R23 9 25 100
C23 25 0 1p
R24 9 26 100
C24 26 0 1p
R25 10 27 100
C25 27 0 1p
R26 10 28 100
C26 28 0 1p
R27 10 29 100
C27 29 0 1p
R28 11 30 100
C28 30 0 1p
R29 11 31 100
C29 31 0 1p
R30 11 32 100
C30 32 0 1p
R31 12 33 100
C31 33 0 1p
R32 12 34 100
C32 34 0 1p
R33 12 35 100
C33 35 0 1p
R34 13 36 100
C34 36 0 1p
R35 13 37 100
C35 37 0 1p
R36 13 38 100
C36 38 0 1p
R37 14 39 100
C37 39 0 1p
R38 14 40 100
C38 40 0 1p
R39 14 41 100
C39 41 0 1p
R40 15 42 100
C40 42 0 1p
R41 15 43 100
C41 43 0 1p
R42 15 44 100
C42 44 0 1p
R43 16 45 100
C43 45 0 1p
R44 16 46 100
C44 46 0 1p
R45 16 47 100
C45 47 0 1p
R46 17 48 100
C46 48 0 1p
R47 17 49 100
C47 49 0 1p
R48 17 50 100
C48 50 0 1p
R49 18 51 100
C49 51 0 1p
R50 18 52 100
C50 52 0 1p
R51 18 53 100
C51 53 0 1p
R52 19 54 100
C52 54 0 1p
R53 19 55 100
C53 55 0 1p
R54 19 56 100
C54 56 0 1p
R55 20 57 100
C55 57 0 1p
R56 20 58 100
C56 58 0 1p
R57 20 59 100
C57 59 0 1p
R58 21 60 100
C58 60 0 1p
R59 21 61 100
C59 61 0 1p
R60 21 62 100
C60 62 0 1p
R61 22 63 100
C61 63 0 1p
R62 22 64 100
C62 64 0 1p
R63 22 65 100
C63 65 0 1p
R64 23 66 100
C64 66 0 1p
R65 23 67 100
C65 67 0 1p
R66 23 68 100
C66 68 0 1p
R67 24 69 100
C67 69 0 1p
R68 24 70 100
C68 70 0 1p
R69 24 71 100
C69 71 0 1p
R70 25 72 100
C70 72 0 1p
R71 25 73 100
C71 73 0 1p
R72 25 74 100
C72 74 0 1p
R73 26 75 100
C73 75 0 1p
R74 26 76 100
C74 76 0 1p
R75 26 77 100
C75 77 0 1p
R76 27 78 100
C76 78 0 1p
R77 27 79 100
C77 79 0 1p
R78 27 80 100
C78 80 0 1p
R79 28 81 100
C79 81 0 1p
R80 28 82 100
C80 82 0 1p
R81 28 83 100
C81 83 0 1p
R82 29 84 100
C82 84 0 1p
R83 29 85 100
C83 85 0 1p
R84 29 86 100
C84 86 0 1p
R85 30 87 100
C85 87 0 1p
R86 30 88 100
C86 88 0 1p
R87 30 89 100
C87 89 0 1p
R88 31 90 100
C88 90 0 1p
R89 31 91 100
C89 91 0 1p
R90 31 92 100
C90 92 0 1p
R91 32 93 100
C91 93 0 1p
R92 32 94 100
C92 94 0 1p
R93 32 95 100
C93 95 0 1p
R94 33 96 100
C94 96 0 1p
R95 33 97 100
C95 97 0 1p
R96 33 98 100
C96 98 0 1p
R97 34 99 100
C97 99 0 1p
R98 34 100 100
C98 100 0 1p
R99 34 101 100
C99 101 0 1p
R100 35 102 100
C100 102 0 1p
R101 35 103 100
C101 103 0 1p
R102 35 104 100
C102 104 0 1p
R103 36 105 100
C103 105 0 1p
R104 36 106 100
C104 106 0 1p
R105 36 107 100
C105 107 0 1p
R106 37 108 100
C106 108 0 1p
R107 37 109 100
C107 109 0 1p
R108 37 110 100
C108 110 0 1p
R109 38 111 100
C109 111 0 1p
R110 38 112 100
C110 112 0 1p
R111 38 113 100
C111 113 0 1p
R112 39 114 100
C112 114 0 1p
R113 39 115 100
C113 115 0 1p
R114 39 116 100
C114 116 0 1p
R115 40 117 100
C115 117 0 1p
R116 40 118 100
C116 118 0 1p
R117 40 119 100
C117 119 0 1p
R118 41 120 100
C118 120 0 1p
R119 41 121 100
C119 121 0 1p
R120 41 122 100
C120 122 0 1p
R121 42 123 100
C121 123 0 1p
R122 42 124 100
C122 124 0 1p
R123 42 125 100
C123 125 0 1p
R124 43 126 100
C124 126 0 1p
R125 43 127 100
C125 127 0 1p
R126 43 128 100
C126 128 0 1p
R127 44 129 100
C127 129 0 1p
R128 44 130 100
C128 130 0 1p
R129 44 131 100
C129 131 0 1p
R130 45 132 100
C130 132 0 1p
R131 45 133 100
C131 133 0 1p
R132 45 134 100
C132 134 0 1p
R133 46 135 100
C133 135 0 1p
R134 46 136 100
C134 136 0 1p
R135 46 137 100
C135 137 0 1p
R136 47 138 100
C136 138 0 1p
R137 47 139 100
C137 139 0 1p
R138 47 140 100
C138 140 0 1p
R139 48 141 100
C139 141 0 1p
R140 48 142 100
C140 142 0 1p
R141 48 143 100
C141 143 0 1p
R142 49 144 100
C142 144 0 1p
R143 49 145 100
C143 145 0 1p
R144 49 146 100
C144 146 0 1p
R145 50 147 100
C145 147 0 1p
R146 50 148 100
C146 148 0 1p
R147 50 149 100
C147 149 0 1p
R148 51 150 100
C148 150 0 1p
R149 51 151 100
C149 151 0 1p
R150 51 152 100
C150 152 0 1p
R151 52 153 100
C151 153 0 1p
R152 52 154 100
C152 154 0 1p
R153 52 155 100
C153 155 0 1p
R154 53 156 100
C154 156 0 1p
R155 53 157 100
C155 157 0 1p
R156 53 158 100
C156 158 0 1p
R157 54 159 100
C157 159 0 1p
R158 54 160 100
C158 160 0 1p
R159 54 161 100
C159 161 0 1p
R160 55 162 100
C160 162 0 1p
R161 55 163 100
C161 163 0 1p
R162 55 164 100
C162 164 0 1p
R163 56 165 100
C163 165 0 1p
R164 56 166 100
C164 166 0 1p
R165 56 167 100
C165 167 0 1p
R166 57 168 100
C166 168 0 1p
R167 57 169 100
C167 169 0 1p
R168 57 170 100
C168 170 0 1p
R169 58 171 100
C169 171 0 1p
R170 58 172 100
C170 172 0 1p
R171 58 173 100
C171 173 0 1p
R172 59 174 100
C172 174 0 1p
R173 59 175 100
C173 175 0 1p
R174 59 176 100
C174 176 0 1p
R175 60 177 100
C175 177 0 1p
R176 60 178 100
C176 178 0 1p
R177 60 179 100
C177 179 0 1p
R178 61 180 100
C178 180 0 1p
R179 61 181 100
C179 181 0 1p
R180 61 182 100
C180 182 0 1p
R181 62 183 100
C181 183 0 1p
R182 62 184 100
C182 184 0 1p
R183 62 185 100
C183 185 0 1p
R184 63 186 100
C184 186 0 1p
R185 63 187 100
C185 187 0 1p
R186 63 188 100
C186 188 0 1p
R187 64 189 100
C187 189 0 1p
R188 64 190 100
C188 190 0 1p
R189 64 191 100
C189 191 0 1p
R190 65 192 100
C190 192 0 1p
R191 65 193 100
C191 193 0 1p
R192 65 194 100
C192 194 0 1p
R193 66 195 100
C193 195 0 1p
R194 66 196 100
C194 196 0 1p
R195 66 197 100
C195 197 0 1p
R196 67 198 100
C196 198 0 1p
R197 67 199 100
C197 199 0 1p
R198 67 200 100
C198 200 0 1p
R199 68 201 100
C199 201 0 1p
R200 68 202 100
C200 202 0 1p
R201 68 203 100
C201 203 0 1p
R202 69 204 100
C202 204 0 1p
R203 69 205 100
C203 205 0 1p
R204 69 206 100
C204 206 0 1p
R205 70 207 100
C205 207 0 1p
R206 70 208 100
C206 208 0 1p
R207 70 209 100
C207 209 0 1p
R208 71 210 100
C208 210 0 1p
R209 71 211 100
C209 211 0 1p
R210 71 212 100
C210 212 0 1p
R211 72 213 100
C211 213 0 1p
R212 72 214 100
C212 214 0 1p
R213 72 215 100
C213 215 0 1p
R214 73 216 100
C214 216 0 1p
R215 73 217 100
C215 217 0 1p
R216 73 218 100
C216 218 0 1p
R217 74 219 100
C217 219 0 1p
R218 74 220 100
C218 220 0 1p
R219 74 221 100
C219 221 0 1p
R220 75 222 100
C220 222 0 1p
R221 75 223 100
C221 223 0 1p
R222 75 224 100
C222 224 0 1p
R223 76 225 100
C223 225 0 1p
R224 76 226 100
C224 226 0 1p
R225 76 227 100
C225 227 0 1p
R226 77 228 100
C226 228 0 1p
R227 77 229 100
C227 229 0 1p
R228 77 230 100
C228 230 0 1p
R229 78 231 100
C229 231 0 1p
R230 78 232 100
C230 232 0 1p
R231 78 233 100
C231 233 0 1p
R232 79 234 100
C232 234 0 1p
R233 79 235 100
C233 235 0 1p
R234 79 236 100
C234 236 0 1p
R235 80 237 100
C235 237 0 1p
R236 80 238 100
C236 238 0 1p
R237 80 239 100
C237 239 0 1p
R238 81 240 100
C238 240 0 1p
R239 81 241 100
C239 241 0 1p
R240 81 242 100
C240 242 0 1p
R241 82 243 100
C241 243 0 1p
R242 82 244 100
C242 244 0 1p
R243 82 245 100
C243 245 0 1p
R244 83 246 100
C244 246 0 1p
R245 83 247 100
C245 247 0 1p
R246 83 248 100
C246 248 0 1p
R247 84 249 100
C247 249 0 1p
R248 84 250 100
C248 250 0 1p
R249 84 251 100
C249 251 0 1p
R250 85 252 100
C250 252 0 1p
R251 85 253 100
C251 253 0 1p
R252 85 254 100
C252 254 0 1p
R253 86 255 100
C253 255 0 1p
R254 86 256 100
C254 256 0 1p
R255 86 257 100
C255 257 0 1p
R256 87 258 100
C256 258 0 1p
R257 87 259 100
C257 259 0 1p
R258 87 260 100
C258 260 0 1p
R259 88 261 100
C259 261 0 1p
R260 88 262 100
C260 262 0 1p
R261 88 263 100
C261 263 0 1p
R262 89 264 100
C262 264 0 1p
R263 89 265 100
C263 265 0 1p
R264 89 266 100
C264 266 0 1p
R265 90 267 100
C265 267 0 1p
R266 90 268 100
C266 268 0 1p
R267 90 269 100
C267 269 0 1p
R268 91 270 100
C268 270 0 1p
R269 91 271 100
C269 271 0 1p
R270 91 272 100
C270 272 0 1p
R271 92 273 100
C271 273 0 1p
R272 92 274 100
C272 274 0 1p
R273 92 275 100
C273 275 0 1p
R274 93 276 100
C274 276 0 1p
R275 93 277 100
C275 277 0 1p
R276 93 278 100
C276 278 0 1p
R277 94 279 100
C277 279 0 1p
R278 94 280 100
C278 280 0 1p
R279 94 281 100
C279 281 0 1p
R280 95 282 100
C280 282 0 1p
R281 95 283 100
C281 283 0 1p
R282 95 284 100
C282 284 0 1p
R283 96 285 100
C283 285 0 1p
R284 96 286 100
C284 286 0 1p
R285 96 287 100
C285 287 0 1p
R286 97 288 100
C286 288 0 1p
R287 97 289 100
C287 289 0 1p
R288 97 290 100
C288 290 0 1p
R289 98 291 100
C289 291 0 1p
R290 98 292 100
C290 292 0 1p
R291 98 293 100
C291 293 0 1p
R292 99 294 100
C292 294 0 1p
R293 99 295 100
C293 295 0 1p
R294 99 296 100
C294 296 0 1p
R295 100 297 100
C295 297 0 1p
R296 100 298 100
C296 298 0 1p
R297 100 299 100
C297 299 0 1p
R298 101 300 100
C298 300 0 1p
R299 101 301 100
C299 301 0 1p
R300 101 302 100
C300 302 0 1p
R301 102 303 100
C301 303 0 1p
R302 102 304 100
C302 304 0 1p
R303 102 305 100
C303 305 0 1p
R304 103 306 100
C304 306 0 1p
R305 103 307 100
C305 307 0 1p
R306 103 308 100
C306 308 0 1p
R307 104 309 100
C307 309 0 1p
R308 104 310 100
C308 310 0 1p
R309 104 311 100
C309 311 0 1p
R310 105 312 100
C310 312 0 1p
R311 105 313 100
C311 313 0 1p
R312 105 314 100
C312 314 0 1p
R313 106 315 100
C313 315 0 1p
R314 106 316 100
C314 316 0 1p
R315 106 317 100
C315 317 0 1p
R316 107 318 100
C316 318 0 1p
R317 107 319 100
C317 319 0 1p
R318 107 320 100
C318 320 0 1p
R319 108 321 100
C319 321 0 1p
R320 108 322 100
C320 322 0 1p
R321 108 323 100
C321 323 0 1p
R322 109 324 100
C322 324 0 1p
R323 109 325 100
C323 325 0 1p
R324 109 326 100
C324 326 0 1p
R325 110 327 100
C325 327 0 1p
R326 110 328 100
C326 328 0 1p
R327 110 329 100
C327 329 0 1p
R328 111 330 100
C328 330 0 1p
R329 111 331 100
C329 331 0 1p
R330 111 332 100
C330 332 0 1p
R331 112 333 100
C331 333 0 1p
R332 112 334 100
C332 334 0 1p
R333 112 335 100
C333 335 0 1p
R334 113 336 100
C334 336 0 1p
R335 113 337 100
C335 337 0 1p
R336 113 338 100
C336 338 0 1p
R337 114 339 100
C337 339 0 1p
R338 114 340 100
C338 340 0 1p
R339 114 341 100
C339 341 0 1p
R340 115 342 100
C340 342 0 1p
R341 115 343 100
C341 343 0 1p
R342 115 344 100
C342 344 0 1p
R343 116 345 100
C343 345 0 1p
R344 116 346 100
C344 346 0 1p
R345 116 347 100
C345 347 0 1p
R346 117 348 100
C346 348 0 1p
R347 117 349 100
C347 349 0 1p
R348 117 350 100
C348 350 0 1p
R349 118 351 100
C349 351 0 1p
R350 118 352 100
C350 352 0 1p
R351 118 353 100
C351 353 0 1p
R352 119 354 100
C352 354 0 1p
R353 119 355 100
C353 355 0 1p
R354 119 356 100
C354 356 0 1p
R355 120 357 100
C355 357 0 1p
R356 120 358 100
C356 358 0 1p
R357 120 359 100
C357 359 0 1p
R358 121 360 100
C358 360 0 1p
R359 121 361 100
C359 361 0 1p
R360 121 362 100
C360 362 0 1p
R361 122 363 100
C361 363 0 1p
R362 122 364 100
C362 364 0 1p
R363 122 365 100
C363 365 0 1p
.OP
.ENDS
