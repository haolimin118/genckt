*scale(5)	circuit type(Clock RC tree (random fanout))

VIN 1 0 1
R0 1 2 100
C0 2 0 1p
R1 2 3 100
C1 3 0 1p
R2 2 4 100
C2 4 0 1p
R3 3 5 100
C3 5 0 1p
R4 3 6 100
C4 6 0 1p
R5 4 7 100
C5 7 0 1p
R6 4 8 100
C6 8 0 1p
R7 4 9 100
C7 9 0 1p
R8 4 10 100
C8 10 0 1p
R9 5 11 100
C9 11 0 1p
R10 6 12 100
C10 12 0 1p
R11 6 13 100
C11 13 0 1p
R12 7 14 100
C12 14 0 1p
R13 7 15 100
C13 15 0 1p
R14 7 16 100
C14 16 0 1p
R15 7 17 100
C15 17 0 1p
R16 7 18 100
C16 18 0 1p
R17 8 19 100
C17 19 0 1p
R18 9 20 100
C18 20 0 1p
R19 9 21 100
C19 21 0 1p
R20 9 22 100
C20 22 0 1p
R21 10 23 100
C21 23 0 1p
R22 10 24 100
C22 24 0 1p
R23 10 25 100
C23 25 0 1p
R24 10 26 100
C24 26 0 1p
R25 10 27 100
C25 27 0 1p
R26 11 28 100
C26 28 0 1p
R27 11 29 100
C27 29 0 1p
R28 11 30 100
C28 30 0 1p
R29 12 31 100
C29 31 0 1p
R30 13 32 100
C30 32 0 1p
R31 13 33 100
C31 33 0 1p
R32 13 34 100
C32 34 0 1p
R33 13 35 100
C33 35 0 1p
R34 13 36 100
C34 36 0 1p
R35 14 37 100
C35 37 0 1p
R36 14 38 100
C36 38 0 1p
R37 14 39 100
C37 39 0 1p
R38 15 40 100
C38 40 0 1p
R39 15 41 100
C39 41 0 1p
R40 15 42 100
C40 42 0 1p
R41 15 43 100
C41 43 0 1p
R42 15 44 100
C42 44 0 1p
R43 16 45 100
C43 45 0 1p
R44 16 46 100
C44 46 0 1p
R45 16 47 100
C45 47 0 1p
R46 17 48 100
C46 48 0 1p
R47 17 49 100
C47 49 0 1p
R48 17 50 100
C48 50 0 1p
R49 17 51 100
C49 51 0 1p
R50 17 52 100
C50 52 0 1p
R51 18 53 100
C51 53 0 1p
R52 18 54 100
C52 54 0 1p
R53 19 55 100
C53 55 0 1p
R54 19 56 100
C54 56 0 1p
R55 20 57 100
C55 57 0 1p
R56 20 58 100
C56 58 0 1p
R57 21 59 100
C57 59 0 1p
R58 21 60 100
C58 60 0 1p
R59 21 61 100
C59 61 0 1p
R60 21 62 100
C60 62 0 1p
R61 21 63 100
C61 63 0 1p
R62 22 64 100
C62 64 0 1p
R63 22 65 100
C63 65 0 1p
R64 22 66 100
C64 66 0 1p
R65 22 67 100
C65 67 0 1p
R66 22 68 100
C66 68 0 1p
R67 23 69 100
C67 69 0 1p
R68 23 70 100
C68 70 0 1p
R69 24 71 100
C69 71 0 1p
R70 24 72 100
C70 72 0 1p
R71 24 73 100
C71 73 0 1p
R72 25 74 100
C72 74 0 1p
R73 25 75 100
C73 75 0 1p
R74 25 76 100
C74 76 0 1p
R75 25 77 100
C75 77 0 1p
R76 25 78 100
C76 78 0 1p
R77 26 79 100
C77 79 0 1p
R78 27 80 100
C78 80 0 1p
R79 28 81 100
C79 81 0 1p
R80 28 82 100
C80 82 0 1p
R81 28 83 100
C81 83 0 1p
R82 28 84 100
C82 84 0 1p
R83 28 85 100
C83 85 0 1p
R84 29 86 100
C84 86 0 1p
R85 29 87 100
C85 87 0 1p
R86 29 88 100
C86 88 0 1p
R87 30 89 100
C87 89 0 1p
R88 30 90 100
C88 90 0 1p
R89 30 91 100
C89 91 0 1p
R90 31 92 100
C90 92 0 1p
R91 31 93 100
C91 93 0 1p
R92 31 94 100
C92 94 0 1p
R93 31 95 100
C93 95 0 1p
R94 31 96 100
C94 96 0 1p
R95 32 97 100
C95 97 0 1p
R96 32 98 100
C96 98 0 1p
R97 33 99 100
C97 99 0 1p
R98 33 100 100
C98 100 0 1p
R99 33 101 100
C99 101 0 1p
R100 33 102 100
C100 102 0 1p
R101 33 103 100
C101 103 0 1p
R102 34 104 100
C102 104 0 1p
R103 34 105 100
C103 105 0 1p
R104 34 106 100
C104 106 0 1p
R105 34 107 100
C105 107 0 1p
R106 35 108 100
C106 108 0 1p
R107 36 109 100
C107 109 0 1p
R108 37 110 100
C108 110 0 1p
R109 37 111 100
C109 111 0 1p
R110 37 112 100
C110 112 0 1p
R111 37 113 100
C111 113 0 1p
R112 37 114 100
C112 114 0 1p
R113 38 115 100
C113 115 0 1p
R114 38 116 100
C114 116 0 1p
R115 38 117 100
C115 117 0 1p
R116 38 118 100
C116 118 0 1p
R117 38 119 100
C117 119 0 1p
R118 39 120 100
C118 120 0 1p
R119 39 121 100
C119 121 0 1p
R120 39 122 100
C120 122 0 1p
R121 40 123 100
C121 123 0 1p
R122 40 124 100
C122 124 0 1p
R123 41 125 100
C123 125 0 1p
R124 41 126 100
C124 126 0 1p
R125 41 127 100
C125 127 0 1p
R126 42 128 100
C126 128 0 1p
R127 43 129 100
C127 129 0 1p
R128 43 130 100
C128 130 0 1p
R129 43 131 100
C129 131 0 1p
R130 43 132 100
C130 132 0 1p
R131 44 133 100
C131 133 0 1p
R132 44 134 100
C132 134 0 1p
R133 44 135 100
C133 135 0 1p
R134 45 136 100
C134 136 0 1p
R135 46 137 100
C135 137 0 1p
R136 46 138 100
C136 138 0 1p
R137 46 139 100
C137 139 0 1p
R138 47 140 100
C138 140 0 1p
R139 47 141 100
C139 141 0 1p
R140 47 142 100
C140 142 0 1p
R141 47 143 100
C141 143 0 1p
R142 48 144 100
C142 144 0 1p
R143 49 145 100
C143 145 0 1p
R144 49 146 100
C144 146 0 1p
R145 49 147 100
C145 147 0 1p
R146 50 148 100
C146 148 0 1p
R147 50 149 100
C147 149 0 1p
R148 50 150 100
C148 150 0 1p
R149 50 151 100
C149 151 0 1p
R150 51 152 100
C150 152 0 1p
R151 52 153 100
C151 153 0 1p
R152 52 154 100
C152 154 0 1p
R153 52 155 100
C153 155 0 1p
R154 52 156 100
C154 156 0 1p
R155 52 157 100
C155 157 0 1p
R156 53 158 100
C156 158 0 1p
R157 53 159 100
C157 159 0 1p
R158 53 160 100
C158 160 0 1p
R159 53 161 100
C159 161 0 1p
R160 54 162 100
C160 162 0 1p
R161 54 163 100
C161 163 0 1p
R162 55 164 100
C162 164 0 1p
R163 55 165 100
C163 165 0 1p
R164 55 166 100
C164 166 0 1p
R165 56 167 100
C165 167 0 1p
R166 56 168 100
C166 168 0 1p
R167 56 169 100
C167 169 0 1p
R168 56 170 100
C168 170 0 1p
R169 57 171 100
C169 171 0 1p
R170 58 172 100
C170 172 0 1p
R171 58 173 100
C171 173 0 1p
R172 58 174 100
C172 174 0 1p
R173 58 175 100
C173 175 0 1p
R174 59 176 100
C174 176 0 1p
R175 60 177 100
C175 177 0 1p
R176 60 178 100
C176 178 0 1p
R177 61 179 100
C177 179 0 1p
R178 61 180 100
C178 180 0 1p
R179 61 181 100
C179 181 0 1p
R180 61 182 100
C180 182 0 1p
R181 61 183 100
C181 183 0 1p
R182 62 184 100
C182 184 0 1p
R183 63 185 100
C183 185 0 1p
R184 63 186 100
C184 186 0 1p
R185 63 187 100
C185 187 0 1p
R186 64 188 100
C186 188 0 1p
R187 64 189 100
C187 189 0 1p
R188 65 190 100
C188 190 0 1p
R189 65 191 100
C189 191 0 1p
R190 65 192 100
C190 192 0 1p
R191 66 193 100
C191 193 0 1p
R192 67 194 100
C192 194 0 1p
R193 67 195 100
C193 195 0 1p
R194 68 196 100
C194 196 0 1p
R195 69 197 100
C195 197 0 1p
R196 69 198 100
C196 198 0 1p
R197 69 199 100
C197 199 0 1p
R198 70 200 100
C198 200 0 1p
R199 70 201 100
C199 201 0 1p
R200 70 202 100
C200 202 0 1p
R201 70 203 100
C201 203 0 1p
R202 70 204 100
C202 204 0 1p
R203 71 205 100
C203 205 0 1p
R204 71 206 100
C204 206 0 1p
R205 71 207 100
C205 207 0 1p
R206 71 208 100
C206 208 0 1p
R207 72 209 100
C207 209 0 1p
R208 73 210 100
C208 210 0 1p
R209 73 211 100
C209 211 0 1p
R210 73 212 100
C210 212 0 1p
R211 74 213 100
C211 213 0 1p
R212 74 214 100
C212 214 0 1p
R213 75 215 100
C213 215 0 1p
R214 76 216 100
C214 216 0 1p
R215 76 217 100
C215 217 0 1p
R216 76 218 100
C216 218 0 1p
R217 76 219 100
C217 219 0 1p
R218 76 220 100
C218 220 0 1p
R219 77 221 100
C219 221 0 1p
R220 77 222 100
C220 222 0 1p
R221 77 223 100
C221 223 0 1p
R222 77 224 100
C222 224 0 1p
R223 78 225 100
C223 225 0 1p
R224 78 226 100
C224 226 0 1p
R225 78 227 100
C225 227 0 1p
R226 78 228 100
C226 228 0 1p
R227 79 229 100
C227 229 0 1p
R228 79 230 100
C228 230 0 1p
R229 79 231 100
C229 231 0 1p
R230 79 232 100
C230 232 0 1p
R231 80 233 100
C231 233 0 1p
.OP
.ENDS
