*scale(3)	circuit type(Clock R tree (random fanout))

VIN 1 0 1
R0 1 2 100
R1 2 3 100
R2 2 4 100
R3 3 5 100
R4 3 6 100
R5 3 7 100
R6 4 8 100
R7 4 9 100
R8 4 10 100
R9 5 11 100
R10 6 12 100
R11 6 13 100
R12 6 14 100
R13 7 15 100
R14 7 16 100
R15 7 17 100
R16 8 18 100
R17 9 19 100
R18 9 20 100
R19 9 21 100
R20 10 22 100
R21 10 23 100
R22 11 24 100
R23 11 25 100
R24 11 26 100
R25 12 27 100
R26 12 28 100
R27 13 29 100
R28 13 30 100
R29 14 31 100
R30 14 32 100
R31 14 33 100
R32 15 34 100
R33 15 35 100
R34 16 36 100
R35 16 37 100
R36 16 38 100
R37 17 39 100
R38 17 40 100
R39 17 41 100
R40 18 42 100
R41 18 43 100
R42 19 44 100
R43 19 45 100
R44 20 46 100
R45 20 47 100
R46 21 48 100
R47 21 49 100
R48 22 50 100
R49 22 51 100
R50 23 52 100
R51 24 0 100
R52 24 0 100
R53 25 0 100
R54 25 0 100
R55 25 0 100
R56 26 0 100
R57 26 0 100
R58 26 0 100
R59 27 0 100
R60 27 0 100
R61 28 0 100
R62 28 0 100
R63 29 0 100
R64 29 0 100
R65 30 0 100
R66 30 0 100
R67 30 0 100
R68 31 0 100
R69 31 0 100
R70 32 0 100
R71 32 0 100
R72 33 0 100
R73 33 0 100
R74 33 0 100
R75 34 0 100
R76 34 0 100
R77 34 0 100
R78 35 0 100
R79 35 0 100
R80 36 0 100
R81 36 0 100
R82 36 0 100
R83 37 0 100
R84 37 0 100
R85 38 0 100
R86 38 0 100
R87 38 0 100
R88 39 0 100
R89 39 0 100
R90 40 0 100
R91 41 0 100
R92 41 0 100
R93 41 0 100
R94 42 0 100
R95 43 0 100
R96 44 0 100
R97 45 0 100
R98 46 0 100
R99 46 0 100
R100 46 0 100
R101 47 0 100
R102 48 0 100
R103 48 0 100
R104 49 0 100
R105 50 0 100
R106 50 0 100
R107 51 0 100
R108 51 0 100
R109 51 0 100
R110 52 0 100
.OP
.ENDS
