*scale(5)	circuit type(Clock R tree (random fanout))

VIN 1 0 1
R0 1 2 100
R1 2 3 100
R2 2 4 100
R3 2 5 100
R4 3 6 100
R5 3 7 100
R6 3 8 100
R7 3 9 100
R8 4 10 100
R9 4 11 100
R10 4 12 100
R11 4 13 100
R12 5 14 100
R13 5 15 100
R14 5 16 100
R15 5 17 100
R16 5 18 100
R17 6 19 100
R18 6 20 100
R19 7 21 100
R20 7 22 100
R21 7 23 100
R22 7 24 100
R23 7 25 100
R24 8 26 100
R25 8 27 100
R26 8 28 100
R27 9 29 100
R28 9 30 100
R29 9 31 100
R30 9 32 100
R31 10 33 100
R32 10 34 100
R33 10 35 100
R34 11 36 100
R35 12 37 100
R36 12 38 100
R37 12 39 100
R38 12 40 100
R39 12 41 100
R40 13 42 100
R41 14 43 100
R42 14 44 100
R43 14 45 100
R44 14 46 100
R45 15 47 100
R46 15 48 100
R47 15 49 100
R48 15 50 100
R49 16 51 100
R50 16 52 100
R51 16 53 100
R52 16 54 100
R53 17 55 100
R54 17 56 100
R55 17 57 100
R56 17 58 100
R57 17 59 100
R58 18 60 100
R59 18 61 100
R60 19 62 100
R61 19 63 100
R62 20 64 100
R63 21 65 100
R64 21 66 100
R65 22 67 100
R66 22 68 100
R67 22 69 100
R68 22 70 100
R69 23 71 100
R70 24 72 100
R71 25 73 100
R72 25 74 100
R73 26 75 100
R74 26 76 100
R75 27 77 100
R76 27 78 100
R77 28 79 100
R78 28 80 100
R79 28 81 100
R80 28 82 100
R81 28 83 100
R82 29 84 100
R83 29 85 100
R84 30 86 100
R85 30 87 100
R86 30 88 100
R87 30 89 100
R88 30 90 100
R89 31 91 100
R90 31 92 100
R91 31 93 100
R92 31 94 100
R93 31 95 100
R94 32 96 100
R95 33 97 100
R96 34 98 100
R97 35 99 100
R98 35 100 100
R99 35 101 100
R100 35 102 100
R101 36 103 100
R102 37 104 100
R103 37 105 100
R104 37 106 100
R105 37 107 100
R106 37 108 100
R107 38 109 100
R108 38 110 100
R109 38 111 100
R110 39 112 100
R111 39 113 100
R112 39 114 100
R113 39 115 100
R114 39 116 100
R115 40 117 100
R116 40 118 100
R117 40 119 100
R118 40 120 100
R119 41 121 100
R120 41 122 100
R121 41 123 100
R122 41 124 100
R123 42 125 100
R124 42 126 100
R125 42 127 100
R126 42 128 100
R127 43 129 100
R128 43 130 100
R129 43 131 100
R130 43 132 100
R131 43 133 100
R132 44 134 100
R133 44 135 100
R134 44 136 100
R135 45 137 100
R136 45 138 100
R137 45 139 100
R138 46 140 100
R139 46 141 100
R140 46 142 100
R141 47 143 100
R142 48 144 100
R143 48 145 100
R144 49 146 100
R145 49 147 100
R146 49 148 100
R147 50 149 100
R148 50 150 100
R149 51 151 100
R150 52 152 100
R151 53 153 100
R152 53 154 100
R153 54 155 100
R154 54 156 100
R155 55 157 100
R156 55 158 100
R157 55 159 100
R158 56 160 100
R159 57 161 100
R160 58 162 100
R161 58 163 100
R162 59 164 100
R163 59 165 100
R164 59 166 100
R165 59 167 100
R166 59 168 100
R167 60 169 100
R168 61 170 100
R169 61 171 100
R170 61 172 100
R171 62 0 100
R172 62 0 100
R173 63 0 100
R174 63 0 100
R175 63 0 100
R176 63 0 100
R177 63 0 100
R178 64 0 100
R179 64 0 100
R180 64 0 100
R181 64 0 100
R182 65 0 100
R183 65 0 100
R184 65 0 100
R185 65 0 100
R186 65 0 100
R187 66 0 100
R188 66 0 100
R189 67 0 100
R190 67 0 100
R191 67 0 100
R192 68 0 100
R193 69 0 100
R194 69 0 100
R195 70 0 100
R196 70 0 100
R197 70 0 100
R198 70 0 100
R199 71 0 100
R200 71 0 100
R201 71 0 100
R202 72 0 100
R203 73 0 100
R204 73 0 100
R205 73 0 100
R206 73 0 100
R207 74 0 100
R208 74 0 100
R209 74 0 100
R210 75 0 100
R211 76 0 100
R212 77 0 100
R213 78 0 100
R214 79 0 100
R215 80 0 100
R216 80 0 100
R217 80 0 100
R218 80 0 100
R219 80 0 100
R220 81 0 100
R221 81 0 100
R222 81 0 100
R223 81 0 100
R224 81 0 100
R225 82 0 100
R226 82 0 100
R227 82 0 100
R228 82 0 100
R229 83 0 100
R230 83 0 100
R231 83 0 100
R232 83 0 100
R233 84 0 100
R234 84 0 100
R235 84 0 100
R236 85 0 100
R237 86 0 100
R238 86 0 100
R239 86 0 100
R240 87 0 100
R241 87 0 100
R242 87 0 100
R243 88 0 100
R244 88 0 100
R245 88 0 100
R246 88 0 100
R247 88 0 100
R248 89 0 100
R249 89 0 100
R250 89 0 100
R251 90 0 100
R252 90 0 100
R253 90 0 100
R254 91 0 100
R255 91 0 100
R256 91 0 100
R257 92 0 100
R258 92 0 100
R259 92 0 100
R260 92 0 100
R261 93 0 100
R262 93 0 100
R263 93 0 100
R264 94 0 100
R265 95 0 100
R266 95 0 100
R267 95 0 100
R268 96 0 100
R269 96 0 100
R270 96 0 100
R271 96 0 100
R272 96 0 100
R273 97 0 100
R274 97 0 100
R275 97 0 100
R276 97 0 100
R277 97 0 100
R278 98 0 100
R279 99 0 100
R280 99 0 100
R281 99 0 100
R282 100 0 100
R283 100 0 100
R284 100 0 100
R285 101 0 100
R286 102 0 100
R287 103 0 100
R288 103 0 100
R289 103 0 100
R290 103 0 100
R291 104 0 100
R292 105 0 100
R293 105 0 100
R294 106 0 100
R295 106 0 100
R296 106 0 100
R297 107 0 100
R298 107 0 100
R299 107 0 100
R300 107 0 100
R301 108 0 100
R302 109 0 100
R303 109 0 100
R304 109 0 100
R305 110 0 100
R306 110 0 100
R307 110 0 100
R308 110 0 100
R309 111 0 100
R310 111 0 100
R311 111 0 100
R312 111 0 100
R313 111 0 100
R314 112 0 100
R315 112 0 100
R316 112 0 100
R317 112 0 100
R318 113 0 100
R319 113 0 100
R320 113 0 100
R321 114 0 100
R322 114 0 100
R323 114 0 100
R324 114 0 100
R325 115 0 100
R326 115 0 100
R327 115 0 100
R328 116 0 100
R329 116 0 100
R330 116 0 100
R331 117 0 100
R332 117 0 100
R333 117 0 100
R334 118 0 100
R335 118 0 100
R336 118 0 100
R337 118 0 100
R338 119 0 100
R339 119 0 100
R340 119 0 100
R341 119 0 100
R342 119 0 100
R343 120 0 100
R344 120 0 100
R345 120 0 100
R346 121 0 100
R347 121 0 100
R348 121 0 100
R349 122 0 100
R350 122 0 100
R351 122 0 100
R352 122 0 100
R353 123 0 100
R354 124 0 100
R355 125 0 100
R356 125 0 100
R357 125 0 100
R358 125 0 100
R359 126 0 100
R360 126 0 100
R361 126 0 100
R362 127 0 100
R363 127 0 100
R364 127 0 100
R365 128 0 100
R366 128 0 100
R367 128 0 100
R368 129 0 100
R369 129 0 100
R370 130 0 100
R371 131 0 100
R372 132 0 100
R373 133 0 100
R374 133 0 100
R375 134 0 100
R376 134 0 100
R377 134 0 100
R378 134 0 100
R379 134 0 100
R380 135 0 100
R381 135 0 100
R382 135 0 100
R383 136 0 100
R384 137 0 100
R385 137 0 100
R386 137 0 100
R387 137 0 100
R388 137 0 100
R389 138 0 100
R390 138 0 100
R391 138 0 100
R392 138 0 100
R393 138 0 100
R394 139 0 100
R395 139 0 100
R396 139 0 100
R397 139 0 100
R398 139 0 100
R399 140 0 100
R400 140 0 100
R401 140 0 100
R402 141 0 100
R403 141 0 100
R404 142 0 100
R405 142 0 100
R406 142 0 100
R407 142 0 100
R408 142 0 100
R409 143 0 100
R410 143 0 100
R411 143 0 100
R412 143 0 100
R413 143 0 100
R414 144 0 100
R415 144 0 100
R416 144 0 100
R417 144 0 100
R418 144 0 100
R419 145 0 100
R420 145 0 100
R421 145 0 100
R422 145 0 100
R423 146 0 100
R424 146 0 100
R425 146 0 100
R426 146 0 100
R427 147 0 100
R428 148 0 100
R429 148 0 100
R430 148 0 100
R431 148 0 100
R432 148 0 100
R433 149 0 100
R434 149 0 100
R435 149 0 100
R436 150 0 100
R437 150 0 100
R438 151 0 100
R439 151 0 100
R440 152 0 100
R441 152 0 100
R442 152 0 100
R443 152 0 100
R444 153 0 100
R445 153 0 100
R446 153 0 100
R447 154 0 100
R448 154 0 100
R449 155 0 100
R450 156 0 100
R451 156 0 100
R452 157 0 100
R453 157 0 100
R454 158 0 100
R455 159 0 100
R456 159 0 100
R457 159 0 100
R458 160 0 100
R459 160 0 100
R460 160 0 100
R461 161 0 100
R462 162 0 100
R463 162 0 100
R464 162 0 100
R465 162 0 100
R466 162 0 100
R467 163 0 100
R468 163 0 100
R469 164 0 100
R470 164 0 100
R471 164 0 100
R472 164 0 100
R473 165 0 100
R474 165 0 100
R475 165 0 100
R476 165 0 100
R477 166 0 100
R478 167 0 100
R479 168 0 100
R480 168 0 100
R481 168 0 100
R482 169 0 100
R483 169 0 100
R484 169 0 100
R485 169 0 100
R486 169 0 100
R487 170 0 100
R488 170 0 100
R489 171 0 100
R490 171 0 100
R491 171 0 100
R492 171 0 100
R493 172 0 100
R494 172 0 100
.OP
.ENDS
