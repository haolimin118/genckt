*scale(3)	circuit type(Clock RC tree (random fanout))

VIN 1 0 1
R0 1 2 100
C0 2 0 1p
R1 2 3 100
C1 3 0 1p
R2 2 4 100
C2 4 0 1p
R3 2 5 100
C3 5 0 1p
R4 3 6 100
C4 6 0 1p
R5 3 7 100
C5 7 0 1p
R6 4 8 100
C6 8 0 1p
R7 5 9 100
C7 9 0 1p
R8 6 10 100
C8 10 0 1p
R9 6 11 100
C9 11 0 1p
R10 7 12 100
C10 12 0 1p
R11 7 13 100
C11 13 0 1p
R12 7 14 100
C12 14 0 1p
R13 8 15 100
C13 15 0 1p
R14 9 16 100
C14 16 0 1p
R15 9 17 100
C15 17 0 1p
R16 10 18 100
C16 18 0 1p
R17 10 19 100
C17 19 0 1p
R18 10 20 100
C18 20 0 1p
R19 11 21 100
C19 21 0 1p
R20 11 22 100
C20 22 0 1p
R21 11 23 100
C21 23 0 1p
R22 12 24 100
C22 24 0 1p
R23 12 25 100
C23 25 0 1p
R24 13 26 100
C24 26 0 1p
R25 13 27 100
C25 27 0 1p
R26 14 28 100
C26 28 0 1p
R27 14 29 100
C27 29 0 1p
R28 15 30 100
C28 30 0 1p
R29 16 31 100
C29 31 0 1p
R30 16 32 100
C30 32 0 1p
R31 17 33 100
C31 33 0 1p
R32 17 34 100
C32 34 0 1p
R33 18 35 100
C33 35 0 1p
R34 19 36 100
C34 36 0 1p
R35 19 37 100
C35 37 0 1p
R36 20 38 100
C36 38 0 1p
R37 21 39 100
C37 39 0 1p
R38 21 40 100
C38 40 0 1p
R39 21 41 100
C39 41 0 1p
R40 22 42 100
C40 42 0 1p
R41 23 43 100
C41 43 0 1p
R42 23 44 100
C42 44 0 1p
R43 23 45 100
C43 45 0 1p
R44 24 46 100
C44 46 0 1p
R45 25 47 100
C45 47 0 1p
R46 25 48 100
C46 48 0 1p
R47 26 49 100
C47 49 0 1p
R48 26 50 100
C48 50 0 1p
R49 27 51 100
C49 51 0 1p
R50 27 52 100
C50 52 0 1p
R51 28 53 100
C51 53 0 1p
R52 29 54 100
C52 54 0 1p
R53 29 55 100
C53 55 0 1p
R54 30 56 100
C54 56 0 1p
R55 30 57 100
C55 57 0 1p
R56 31 58 100
C56 58 0 1p
R57 31 59 100
C57 59 0 1p
R58 32 60 100
C58 60 0 1p
R59 33 61 100
C59 61 0 1p
R60 34 62 100
C60 62 0 1p
R61 34 63 100
C61 63 0 1p
.OP
.ENDS
