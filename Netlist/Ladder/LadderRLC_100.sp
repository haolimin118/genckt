*scale(100)	circuit type(RLC ladder)

VIN 1 0 1
C0 1 0 1p
R1 1 2 100
L1 2 3 1m
C1 3 0 1p
R2 3 4 100
L2 4 5 1m
C2 5 0 1p
R3 5 6 100
L3 6 7 1m
C3 7 0 1p
R4 7 8 100
L4 8 9 1m
C4 9 0 1p
R5 9 10 100
L5 10 11 1m
C5 11 0 1p
R6 11 12 100
L6 12 13 1m
C6 13 0 1p
R7 13 14 100
L7 14 15 1m
C7 15 0 1p
R8 15 16 100
L8 16 17 1m
C8 17 0 1p
R9 17 18 100
L9 18 19 1m
C9 19 0 1p
R10 19 20 100
L10 20 21 1m
C10 21 0 1p
R11 21 22 100
L11 22 23 1m
C11 23 0 1p
R12 23 24 100
L12 24 25 1m
C12 25 0 1p
R13 25 26 100
L13 26 27 1m
C13 27 0 1p
R14 27 28 100
L14 28 29 1m
C14 29 0 1p
R15 29 30 100
L15 30 31 1m
C15 31 0 1p
R16 31 32 100
L16 32 33 1m
C16 33 0 1p
R17 33 34 100
L17 34 35 1m
C17 35 0 1p
R18 35 36 100
L18 36 37 1m
C18 37 0 1p
R19 37 38 100
L19 38 39 1m
C19 39 0 1p
R20 39 40 100
L20 40 41 1m
C20 41 0 1p
R21 41 42 100
L21 42 43 1m
C21 43 0 1p
R22 43 44 100
L22 44 45 1m
C22 45 0 1p
R23 45 46 100
L23 46 47 1m
C23 47 0 1p
R24 47 48 100
L24 48 49 1m
C24 49 0 1p
R25 49 50 100
L25 50 51 1m
C25 51 0 1p
R26 51 52 100
L26 52 53 1m
C26 53 0 1p
R27 53 54 100
L27 54 55 1m
C27 55 0 1p
R28 55 56 100
L28 56 57 1m
C28 57 0 1p
R29 57 58 100
L29 58 59 1m
C29 59 0 1p
R30 59 60 100
L30 60 61 1m
C30 61 0 1p
R31 61 62 100
L31 62 63 1m
C31 63 0 1p
R32 63 64 100
L32 64 65 1m
C32 65 0 1p
R33 65 66 100
L33 66 67 1m
C33 67 0 1p
R34 67 68 100
L34 68 69 1m
C34 69 0 1p
R35 69 70 100
L35 70 71 1m
C35 71 0 1p
R36 71 72 100
L36 72 73 1m
C36 73 0 1p
R37 73 74 100
L37 74 75 1m
C37 75 0 1p
R38 75 76 100
L38 76 77 1m
C38 77 0 1p
R39 77 78 100
L39 78 79 1m
C39 79 0 1p
R40 79 80 100
L40 80 81 1m
C40 81 0 1p
R41 81 82 100
L41 82 83 1m
C41 83 0 1p
R42 83 84 100
L42 84 85 1m
C42 85 0 1p
R43 85 86 100
L43 86 87 1m
C43 87 0 1p
R44 87 88 100
L44 88 89 1m
C44 89 0 1p
R45 89 90 100
L45 90 91 1m
C45 91 0 1p
R46 91 92 100
L46 92 93 1m
C46 93 0 1p
R47 93 94 100
L47 94 95 1m
C47 95 0 1p
R48 95 96 100
L48 96 97 1m
C48 97 0 1p
R49 97 98 100
L49 98 99 1m
C49 99 0 1p
R50 99 100 100
L50 100 101 1m
C50 101 0 1p
R51 101 102 100
L51 102 103 1m
C51 103 0 1p
R52 103 104 100
L52 104 105 1m
C52 105 0 1p
R53 105 106 100
L53 106 107 1m
C53 107 0 1p
R54 107 108 100
L54 108 109 1m
C54 109 0 1p
R55 109 110 100
L55 110 111 1m
C55 111 0 1p
R56 111 112 100
L56 112 113 1m
C56 113 0 1p
R57 113 114 100
L57 114 115 1m
C57 115 0 1p
R58 115 116 100
L58 116 117 1m
C58 117 0 1p
R59 117 118 100
L59 118 119 1m
C59 119 0 1p
R60 119 120 100
L60 120 121 1m
C60 121 0 1p
R61 121 122 100
L61 122 123 1m
C61 123 0 1p
R62 123 124 100
L62 124 125 1m
C62 125 0 1p
R63 125 126 100
L63 126 127 1m
C63 127 0 1p
R64 127 128 100
L64 128 129 1m
C64 129 0 1p
R65 129 130 100
L65 130 131 1m
C65 131 0 1p
R66 131 132 100
L66 132 133 1m
C66 133 0 1p
R67 133 134 100
L67 134 135 1m
C67 135 0 1p
R68 135 136 100
L68 136 137 1m
C68 137 0 1p
R69 137 138 100
L69 138 139 1m
C69 139 0 1p
R70 139 140 100
L70 140 141 1m
C70 141 0 1p
R71 141 142 100
L71 142 143 1m
C71 143 0 1p
R72 143 144 100
L72 144 145 1m
C72 145 0 1p
R73 145 146 100
L73 146 147 1m
C73 147 0 1p
R74 147 148 100
L74 148 149 1m
C74 149 0 1p
R75 149 150 100
L75 150 151 1m
C75 151 0 1p
R76 151 152 100
L76 152 153 1m
C76 153 0 1p
R77 153 154 100
L77 154 155 1m
C77 155 0 1p
R78 155 156 100
L78 156 157 1m
C78 157 0 1p
R79 157 158 100
L79 158 159 1m
C79 159 0 1p
R80 159 160 100
L80 160 161 1m
C80 161 0 1p
R81 161 162 100
L81 162 163 1m
C81 163 0 1p
R82 163 164 100
L82 164 165 1m
C82 165 0 1p
R83 165 166 100
L83 166 167 1m
C83 167 0 1p
R84 167 168 100
L84 168 169 1m
C84 169 0 1p
R85 169 170 100
L85 170 171 1m
C85 171 0 1p
R86 171 172 100
L86 172 173 1m
C86 173 0 1p
R87 173 174 100
L87 174 175 1m
C87 175 0 1p
R88 175 176 100
L88 176 177 1m
C88 177 0 1p
R89 177 178 100
L89 178 179 1m
C89 179 0 1p
R90 179 180 100
L90 180 181 1m
C90 181 0 1p
R91 181 182 100
L91 182 183 1m
C91 183 0 1p
R92 183 184 100
L92 184 185 1m
C92 185 0 1p
R93 185 186 100
L93 186 187 1m
C93 187 0 1p
R94 187 188 100
L94 188 189 1m
C94 189 0 1p
R95 189 190 100
L95 190 191 1m
C95 191 0 1p
R96 191 192 100
L96 192 193 1m
C96 193 0 1p
R97 193 194 100
L97 194 195 1m
C97 195 0 1p
R98 195 196 100
L98 196 197 1m
C98 197 0 1p
R99 197 198 100
L99 198 199 1m
C99 199 0 1p
R100 199 200 100
L100 200 201 1m
C100 201 0 1p

.OP
.PRINT V(201)
.ends
