*scale(50)	circuit type(RLC ladder)

VIN 1 0 1
C0 1 0 1p
R1 1 2 100
L1 2 3 1m
C1 3 0 1p
R2 3 4 100
L2 4 5 1m
C2 5 0 1p
R3 5 6 100
L3 6 7 1m
C3 7 0 1p
R4 7 8 100
L4 8 9 1m
C4 9 0 1p
R5 9 10 100
L5 10 11 1m
C5 11 0 1p
R6 11 12 100
L6 12 13 1m
C6 13 0 1p
R7 13 14 100
L7 14 15 1m
C7 15 0 1p
R8 15 16 100
L8 16 17 1m
C8 17 0 1p
R9 17 18 100
L9 18 19 1m
C9 19 0 1p
R10 19 20 100
L10 20 21 1m
C10 21 0 1p
R11 21 22 100
L11 22 23 1m
C11 23 0 1p
R12 23 24 100
L12 24 25 1m
C12 25 0 1p
R13 25 26 100
L13 26 27 1m
C13 27 0 1p
R14 27 28 100
L14 28 29 1m
C14 29 0 1p
R15 29 30 100
L15 30 31 1m
C15 31 0 1p
R16 31 32 100
L16 32 33 1m
C16 33 0 1p
R17 33 34 100
L17 34 35 1m
C17 35 0 1p
R18 35 36 100
L18 36 37 1m
C18 37 0 1p
R19 37 38 100
L19 38 39 1m
C19 39 0 1p
R20 39 40 100
L20 40 41 1m
C20 41 0 1p
R21 41 42 100
L21 42 43 1m
C21 43 0 1p
R22 43 44 100
L22 44 45 1m
C22 45 0 1p
R23 45 46 100
L23 46 47 1m
C23 47 0 1p
R24 47 48 100
L24 48 49 1m
C24 49 0 1p
R25 49 50 100
L25 50 51 1m
C25 51 0 1p
R26 51 52 100
L26 52 53 1m
C26 53 0 1p
R27 53 54 100
L27 54 55 1m
C27 55 0 1p
R28 55 56 100
L28 56 57 1m
C28 57 0 1p
R29 57 58 100
L29 58 59 1m
C29 59 0 1p
R30 59 60 100
L30 60 61 1m
C30 61 0 1p
R31 61 62 100
L31 62 63 1m
C31 63 0 1p
R32 63 64 100
L32 64 65 1m
C32 65 0 1p
R33 65 66 100
L33 66 67 1m
C33 67 0 1p
R34 67 68 100
L34 68 69 1m
C34 69 0 1p
R35 69 70 100
L35 70 71 1m
C35 71 0 1p
R36 71 72 100
L36 72 73 1m
C36 73 0 1p
R37 73 74 100
L37 74 75 1m
C37 75 0 1p
R38 75 76 100
L38 76 77 1m
C38 77 0 1p
R39 77 78 100
L39 78 79 1m
C39 79 0 1p
R40 79 80 100
L40 80 81 1m
C40 81 0 1p
R41 81 82 100
L41 82 83 1m
C41 83 0 1p
R42 83 84 100
L42 84 85 1m
C42 85 0 1p
R43 85 86 100
L43 86 87 1m
C43 87 0 1p
R44 87 88 100
L44 88 89 1m
C44 89 0 1p
R45 89 90 100
L45 90 91 1m
C45 91 0 1p
R46 91 92 100
L46 92 93 1m
C46 93 0 1p
R47 93 94 100
L47 94 95 1m
C47 95 0 1p
R48 95 96 100
L48 96 97 1m
C48 97 0 1p
R49 97 98 100
L49 98 99 1m
C49 99 0 1p
R50 99 100 100
L50 100 101 1m
C50 101 0 1p

.OP
.PRINT V(101)
.ends
